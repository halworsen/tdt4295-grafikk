# Repository halworsen/tdt4295-grafikk (continued)

## KiCad design pcb/tdt4295/tdt4295.kicad_pcb (continued)

Board: 6 copper layers, 209.6 x 139.7 mm, 169 parts (54 on the bottom side), 138 nets.

File pcb/tdt4295/tdt4295_bom_.csv (part):

Component,Description,Part,References,Value,Footprint,Quantity Per PCB,Datasheet,Digi-Key_PN,DK_Datasheet_Link,DK_Detail_Page,Component name,MANUFACTURER,Category,Status,Family,MPN,Manufacturer,MAXIMUM_PACKAGE_HEIGHT,STANDARD,PARTREV
1,Unpolarized capacitor,C,C102,10nF,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,1,~,1276-1009-1-ND,https://media.digikey.com/pdf/Data%20Sheets/Samsung%20PDFs/C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,https://www.digikey.no/product-detail/en/samsung-electro-mec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,CL10B103KB8NNNC,,,,,,,,,
2,Unpolarized capacitor,C,C101 C105 C108 C109 C110 C207 C208 C209 C212 C213 C215 C301 C601,0.1uF,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,13,~,1276-1006-1-ND,https://www.digikey.no/product-detail/en/samsung-electro-mec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,https://www.digikey.no/product-detail/en/samsung-electro-mec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,CL10B104KA8NNNC,,,,,,,,,
3,Unpolarized capacitor,C,C308 C311 C313 C314 C316 C318 C320 C321 C322 C323 C324 C325 C326 C404 C405 C406 C407 C605 C606 C607 C608,470nF,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,21,https://www.farnell.com/datasheets/2048812.pdf,490-3295-1-ND,,https://www.digikey.no/product-detail/en/murata-electronics/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,GRM188R71C474KA88D,,,,,,,,,
4,Unpolarized capacitor,C,C106 C107 C210 C211,1uF,C_0805_2012Metric_Pad1.18x1.45mm_HandSolder,4,www.samsungsem.com/kr/support/product-search/mlcc/CL21B105KOFNNNE.jsp,1276-1026-1-ND,https://www.digikey.no/product-detail/en/samsung-electro-mec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,https://www.digikey.no/product-detail/en/samsung-electro-mec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,CL21B105KOFNNNE,,,,,,,,,
5,Unpolarized capacitor,C,C304 C305 C307 C309 C310 C312 C317 C319 C402 C403 C603 C604,4.7uF,C_0805_2012Metric_Pad1.18x1.45mm_HandSolder,12,,445-7591-1-ND,,https://www.digikey.no/product-detail/no/tdk-corporation/C20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,C2012X7R1A475K125AC,,,,,,,,,
6,Unpolarized capacitor,C,C103 C104 C111 C205 C206 C214,10uF,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,6,~,1276-1038-1-ND,https://www.digikey.no/product-detail/en/samsung-electro-mec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,https://www.digikey.no/product-detail/en/samsung-electro-mec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,CL10A106KQ8NNNC,,,,,,,,,
7,Unpolarized capacitor,C,C203 C204 C216 C217 C218 C219,22uF,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,6,https://media.digikey.com/pdf/Data%20Sheets/Samsung%20PDFs/C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,1276-1193-1-ND,,https://www.digikey.no/product-detail/en/samsung-electro-mec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,CL10A226MQ8NRNC,,,,,,,,,
8,Unpolarized capacitor,C,C302 C315 C401 C602,47uF,C_1210_3225Metric_Pad1.33x2.70mm_HandSolder,4,https://www.farnell.com/datasheets/2047839.pdf,490-6543-1-ND,,https://www.digikey.no/product-detail/no/murata-electronics/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,GRM32ER71A476ME15L,,,,,,,,,
9,Unpolarized capacitor,C,C201 C306,100uF,C_1210_3225Metric_Pad1.33x2.70mm_HandSolder,2,~,1276-3364-1-ND,,https://www.digikey.no/product-detail/en/samsung-electro-mec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,CL32A107MPVNNNE,,,,,,,,,
10,"Polarized capacitor, US symbol",CP1,C202,100uF,C_1210_3225Metric_Pad1.33x2.70mm_HandSolder,1,~,1276-3364-1-ND,,https://www.digikey.no/product-detail/en/samsung-electro-mec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,CL32A107MPVNNNE,,,,,,,,,
11,,T520V337M2R5ATE025,C303,330uF,T520V337M2R5ATE025,1,,399-4105-1-ND,,https://www.digikey.no/product-detail/en/kemet/T520V337M2R5A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,T520V337M2R5ATE025,,,,,,,,,
12,Unpolarized capacitor,C,C501,1nF/250V,8853522100131,1,~,732-8853522100131CT-ND,,https://www.digikey.no/product-detail/en/w%C3%BCrth-elektron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,8853522100131,,,,,,,,,
13,Light emitting diode,LED,D101 D102 D103 D104 D201 D202 D301 D501 D502 D503 D504,LED,LED_1206_3216Metric_Pad1.42x1.75mm_HandSolder,11,~,732-4989-1-ND 1080-1417-1-ND 1080-1415-1-ND,,https://www.digikey.no/product-detail/no/w%C3%BCrth-elektron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 https://www.digikey.no/product-detail/no/everlight-electroni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 https://www.digikey.no/product-detail/no/everlight-electroni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,150120BS75000 QTLP650D2TR QTLP650C4TR,,,,,,,,,
14,Ferrite bead,Ferrite_Bead,FB201,Ferrite_Bead,R_0201_0603Metric_Pad0.64x0.40mm_HandSolder,1,~,587-1828-1-ND,,https://www.digikey.no/en/products/detail/taiyo-yuden/BK0603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,BK0603HS330-T,,,,,,,,,
15,"Generic connector, double row, 02x10, odd/even pin numbering scheme (row 1 odd numbers, row 2 even numbers), script generated (kicad-library-utils/schlib/autogen/connector/)",Conn_02x10_Odd_Even,J101,ARM 20 Pin Debug Header,PinHeader_2x10_P1.27mm_Vertical_SMD,1,~,SAM13960CT-ND,,https://www.digikey.no/product-detail/en/samtec-inc/FTSH-110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,FTSH-110-01-L-DV-K-TR,,,,,,,,,
16,,DM1AA-SF-PEJ(21),J103,DM1AA-SF-PEJ(21),HRS_DM1AA-SF-PEJ(21),1,https://www.hirose.com/product/document?clcode=CL0609-0004-8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,HR845CT-ND,,https://www.digikey.no/product-detail/no/hirose-electric-co-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,DM1AA-SF-PEJ-21,HRS,,,,,,,,
17,"Generic connector, double row, 02x08, odd/even pin numbering scheme (row 1 odd numbers, row 2 even numbers), script generated (kicad-library-utils/schlib/autogen/connector/)",Conn_02x08_Odd_Even,J502,FPGA GPIO,PinHeader_2x08_P2.54mm_Vertical_SMD,1,~,WM17462-ND,,https://www.digikey.no/product-detail/en/molex/0015910160/WM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,0015910160,,,,,,,,,
18,"Generic connector, double row, 02x07, odd/even pin numbering scheme (row 1 odd numbers, row 2 even numbers), script generated (kicad-library-utils/schlib/autogen/connector/)",Conn_02x07_Odd_Even,J301,FPGA__debug,PinHeader_2x07_P2.54mm_Vertical_SMD,1,~,732-5465-5-ND,,https://www.digikey.no/product-detail/en/w%C3%BCrth-elektron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,61001421121,,,,,,,,,
19,"Generic connector, single row, 01x07, script generated (kicad-library-utils/schlib/autogen/connector/)",Conn_01x07,J104,MCU GPIO Header,PinSocket_1x07_P2.54mm_Vertical_SMD_Pin1Right,1,~,WM20569-ND,,https://www.digikey.no/product-detail/en/molex/0878980726/WM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,0878980726,,,,,,,,,
20,"Generic connector, double row, 02x06, odd/even pin numbering scheme (row 1 odd numbers, row 2 even numbers), script generated (kicad-library-utils/schlib/autogen/connector/)",Conn_02x06_Odd_Even,J102,MCU USART1 Header,PinHeader_2x06_P2.54mm_Vertical_SMD,1,~,WM17460-ND,,https://www.digikey.no/product-detail/en/molex/0015910120/WM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,0015910120,,,,,,,,,
21,Inductor,L,L201 L203,1.5uH,L_1008_2520Metric_Pad1.43x2.20mm_HandSolder,2,~,445-175184-1-ND,,https://www.digikey.no/product-detail/en/tdk-corporation/TFM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,TFM252012ALMA1R5MTAA,,,,,,,,,
22,Inductor,L,L202,2.2uH,L_1008_2520Metric_Pad1.43x2.20mm_HandSolder,1,~,490-5114-1-ND,,https://www.digikey.no/product-detail/en/murata-electronics/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,LQM2HPN2R2MG0L,,,,,,,,,
23,CONN RCPT USB2.0 MINI B SMD R/A,690-005-299-043,P201,690-005-299-043,USB_Mini_B_Female_690-005-299-043,1,http://files.edac.net/690-005-299-043.pdf,151-1206-1-ND,http://files.edac.net/690-005-299-043.pdf,https://www.digikey.no/product-detail/en/edac-inc/690-005-29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,690-005-299-043,,"Connectors, Interconnects",Active,"USB, DVI, HDMI Connectors",690-005-299-043,EDAC Inc.,,,
24,Resistor,R,R105 R106,15,RESC6332X120N,2,https://www.te.com/commerce/DocumentDelivery/DDEController?A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,A121147CT-ND,,https://www.digikey.no/product-detail/no/te-connectivity-pas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,352215RFT,,352215RFT,,,,,,,
25,Resistor,R,R107 R108 R109 R308 R518 R519,100,R_1206_3216Metric_Pad1.30x1.75mm_HandSolder,6,https://www.vishay.com/docs/28705/mcx0x0xpro.pdf,RNCP1206FTD100RCT-ND,,https://www.digikey.no/product-detail/no/vishay-beyschlag-dr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 https://www.digikey.no/product-detail/no/vishay-dale/TNPW080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,RNCP1206FTD100R,,MCU08050C1000FP500,,,,,,,
26,Resistor,R,R307 R520 R521 R522 R523 R524 R525 R526 R527 R528 R529 R530 R531 R532 R533,200,R_2512_6332Metric_Pad1.40x3.35mm_HandSolder,15,https://www.te.com/commerce/DocumentDelivery/DDEController?A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,A116015CT-ND,,https://www.digikey.no/product-detail/en/te-connectivity-pas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,3521200RFT,,,,,,,,,
27,Resistor,R,R101 R102 R103 R104 R201 R202,330,R_2512_6332Metric_Pad1.40x3.35mm_HandSolder,6,https://www.seielect.com/catalog/sei-rhc.pdf,RHC2512FT330RCT-ND,,https://www.digikey.no/product-detail/no/stackpole-electroni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,RHC2512FT330R,,,,,,,,,
28,Resistor,R,R507 R508 R509 R510,330,R_0805_2012Metric_Pad1.20x1.40mm_HandSolder,4,https://www.koaspeer.com/pdfs/RK73H.pdf,2019-RK73H2ATTD3300FCT-ND,,https://www.digikey.no/product-detail/no/koa-speer-electroni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,RK73H2ATTD3300F,,,,,,,,,
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
## Commit log (part)

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2021-09-13 Runner dockerfile & helm chart
2021-09-13 update chisel action to run on self-hosted runners
2021-09-13 add indicator LEDs to power supply
2021-09-13 use setup-scala for chisel CI
2021-09-14 fpga power regulator schematics
2021-09-14 power component hierarchical label fix
2021-09-15 implemented assertions
2021-09-15 fix: framebuffer
2021-09-15 feat: connected fb and line drawing
2021-09-15 ESD protection component imported
2021-09-15 add symbols for Giant Gecko&power regulator
2021-09-15 modify power components
2021-09-16 formatting
2021-09-16 more formatting and remove gcd
2021-09-16 Line drawing (#11)
    * feat: added bresenhams line drawing algorithm to project
    * implemented assertions
    * use chisel3 assert instead
    * fix: framebuffer
    * feat: connected fb and line drawing
    * feat: vga, fb and line drawing now interacts
2021-09-16 Start on clock module using built in MMCE2 module
2021-09-16 Clean up project code
2021-09-16 start implementing FPGA spi flash
2021-09-16 feat: added external verilog code for clock
2021-09-16 Connect clock and vga module
2021-09-16 simple efm connections
2021-09-16 Finish labeling/connecting EFM32 pins
2021-09-17 rework some efm wiring according to application notes
2021-09-17 remove analog 3v3 output
2021-09-20 rework power regulator to only use tps54294
2021-09-20 add probe points for all power lines
2021-09-21 add another capacitor :)
2021-09-22 update linedrawing
2021-09-22 Update LineDrawing.scala (#13)
    * Update LineDrawing.scala
    * update linedrawing
    * Update LineDrawing.scala
2021-09-22 feat: added support for 3x3 x 3x3 and 4x1 x 4x4 multiplication
2021-09-22 matrix bonanza
2021-09-22 Add pushbuttons & LEDs to EFM32GG GPIO ports
2021-09-22 3v3 decouplers
2021-09-22 minor schematic fixes
2021-09-23 fix indexing in c calculation in laderman
2021-09-23 update pcb library
2021-09-23 Major restructuring of FPGA outputs
2021-09-23 associate (most) symbols with footprints
2021-09-24 add final footprints, tweak VGA output
2021-09-24 annotation fix
2021-09-24 correct errors spotted by Markus
2021-09-24 add joystick symlib file that was somehow ignored?
2021-09-24 Replace PB4-7 with joysticks
2021-09-24 review stuff
2021-09-26 associate (some) footprints to the symbols
2021-09-27 pcb: Added some more footprints/part numbers
2021-09-27 pcb: correct vga circuit, modify resistor/capacitor sizes
2021-09-28 MCU fixes from review comments
2021-09-28 correct capacitor values, make junctions for IOB34&35
2021-09-28 Setup routing design rules
2021-09-28 add footprints, rename components
2021-09-28 Add debug and write makefile clearer
2021-09-28 associate component links with (almost) every component
2021-09-28 add final footprint, fix path in footprint library
2021-09-28 the absolute minimum effort on pcb routing
2021-09-28 add digikey part numbers, create BOM
2021-09-28 very rough layout of MCU components
2021-09-29 move capacitors to the other side, create power zones for FPGA
2021-09-29 Create Qspi.scala
    Setup core logic for qspi
2021-09-29 Update VGA.scala (#16)
    * Update VGA.scala
    * Update VGA.scala
    * formatting
    * Update VGA.scala
    * Update VGA.scala
2021-09-29 Matrix multiplication (#15)
    * feat: added support for 3x3 x 3x3 and 4x1 x 4x4 multiplication
    * matrix bonanza
    * fix indexing in c calculation in laderman
    * Update Rotation.scala
    * Update Rotation.scala
    * Update Rotation.scala
2021-09-29 start routing pins out from FPGA
2021-09-29 feat: read 8 bits and output value from register
2021-09-29 do a minimal amount of routing for the 2nd power regulator
2021-09-29 more FPGA routing
2021-09-29 track width rules
2021-09-29 fix clearance & unconnected regulator caps
2021-09-29 feat: setup known matrices
    Should probably just set them all to 4d vectors
2021-09-29 All Vectors are now 4D
2021-09-30 placing out components, more routing from FPGA
2021-09-30 Add pretty target for formatting
2021-09-30 declarations for the basic linalg functions
2021-09-30 draft for serializing buffers of structures
2021-09-30 Finish routing voltage regulators
2021-09-30 assorted minor fixes
2021-09-30 add new ferrite bead
2021-09-30 wrap up today's shift in the coal mines
    :')
2021-10-01 make longest connections
2021-10-01 tidy up routing a little bit
2021-10-02 more routing cleanup
2021-10-02 touch up the silkscreen
    header annotations etc.
2021-10-03 put in some 3d models, mostly for fun
2021-10-04 a little more power plane for 1v8
2021-10-04 fix accidental missing fill
2021-10-04 Complete BOM, add new farnell order
2021-10-06 Enable swithcing of coordinates
2021-10-06 Start implementing framebuffer in memory
2021-10-06 Add systemverilog module around bram, and respective blackbox
2021-10-06 Clean up
2021-10-06 update Bugge schematic pdf
2021-10-06 ignore .out
2021-10-06 basic linalg
2021-10-07 Use standard memory instead ov xilinx macro.
    Make the framebuffer work! This adds a simple 640x480 framebuffer and
    connects this to the VGA module. Also adds some example memory buffers
    to load the framebuffer with sample images.
2021-10-07 Fix compilation issue
2021-10-07 Move btn module to it's own file
2021-10-07 simple rotation matrices
2021-10-07 4x4 matrix multiplication
2021-10-07 gitignore DS_strore
2021-10-07 added -lm to makefile to link math.h
2021-10-07 We swap on x coordinates
2021-10-07 Matrix operations (#26)
    * 4x4 matrix multiplication
    * Use modules for calculating matrices instead of whatever the fuck I was doing previously
    * Update Matrix.scala
2021-10-07 remove bram class
2021-10-07 separate serialization translation unit + full data transfer buffer
2021-10-07 some more comments. i also learned how to spell indices and vertices.
2021-10-07 almost done with matrix testing
2021-10-13 Revert "Framebuffer (#23)"
    This reverts commit 0c4a14a2f97e3fc215c1c88c53ebe78f934a105f.
2021-10-13 Make linedrawing work in negative x direction
2021-10-13 Spi Clock driven added
2021-10-13 Polling solution & tests
2021-10-13 Readd linedrawing modules & format all the things
2021-10-14 tests passes
2021-10-14 Ignore SPI test for now
2021-10-14 my thoughts on how to double buffer / clear
2021-10-19 Set up
2021-10-20 think I won't start all of these when's when I set io.start hm
2021-10-20 hardwareifying code
2021-10-20 ready for testing
2021-10-20 Add test code for timer
2021-10-20 Add ADC sampling
2021-10-20 feat: matrix pipeline for reading multiple vertices and multiplying them with same mvp
2021-10-20 feat: clear single pixel in buffer
2021-10-20 Add function for calculating points
2021-10-20 Use separate pins for adc and spi
2021-10-21 3d linalg header
2021-10-21 make 4d trans matrix conform to same api as 3d
2021-10-21 3D linalg for 2D scenes with simple example with rotated square
2021-10-21 Tweak SPI slave and add testbenches
2021-10-21 Update constraint file
2021-10-21 mama mia
2021-10-22 comments about peformance
2021-10-22 making use of hardware counter to reset
2021-10-23 fixed loop to loop [0, 2, 4, 6]
2021-10-27 Add some fault tolreance to linedrawer
2021-10-27 Implement rectangle drawer
2021-10-27 double buffering through mux and swapping out bundles
2021-10-28 feat: added double buffering and clearing
2021-10-28 Added more
2021-11-03 Add testbench for vector-matrix multiplication (& fix linedrawer)
2021-11-03 Fix square drawing
2021-11-03 fixed race condition and buffer overflow
2021-11-04 Fixed syntax errors
2021-11-04 Add color from line array
2021-11-04 Fix timing issue in linedrawer
    This issue was not apparent when drawing only in one spot, but showd
    itself when we try to clear the buffer. We set writeEnable=1 in init2
    state, before the x and y registers were fully initialized. This meant
    that it wrote to the framebuffer one cycle too early, writing the
    previous values in the x and y registers. And since writeEnable was not
    high in init3, it was set in the draw state, one cycle too late again,
2021-11-04 Everything shoud work, but global variables fail
2021-11-05 Small changes to Dataframe format
2021-11-05 Removed dynamic color as it requires too much BRAM
2021-11-06 Fixed Linedrawing so that it also draws the last pixel
2021-11-07 IT WORKS
2021-11-07 Added small animation as standard behaviour
2021-11-09 some stuff
2021-11-09 Added w normalization and point to pixel translation
2021-11-09 dobbel norm
2021-11-11 simple fpga package in main.c
2021-11-11 some comments and no hardcoded array sizes
2021-11-11 Rewrite to use shared values for bit width etc & proper bundles
2021-11-11 feat: point to pixel test ready
2021-11-11 messing around with wires
2021-11-11 Fixed normalization and added some tests
2021-11-12 Add correct constraint file for bugge
2021-11-12 POC implementing rotation of arbitrary points
2021-11-15 Correct pins for SPI on bugge
2021-11-16 Read joysticks, use both edges for buttons, only send when FPGA is ready
2021-11-17 added vsync
2021-11-17 Changed state machine to wait for propagation
2021-11-18 Change all matrix/vector to be FP
2021-11-18 Make FP calculations in matrix correct
2021-11-18 clean plugins sbt
2021-11-19 Add matrix to dataframe over SPI & use that for MVP
2021-11-19 Edit matrix tests to work with FP
    Adds `dsptools` as this is the preferred way to test with FP and
    floating point numbers. The DspTester includes tolerances.
2021-11-19 3d demo!
2021-11-19 3d rendering and w-normalization
    Adds matrix to the dataframe and extends number of points and lines for
    a 3d cube. Also adds a `FixPointDivision` module that uses Vivado IP
    _Floating Point Operator_ modules to perform FixedPoint division used in
    the normalization.
2021-11-20 WIP: try to fix the flickering issue
2021-11-21 Tidy up files and removing unnecessary commented code Feel free to go over and add back in if somethings's needed
2021-11-21 Send matrix in natural order
2021-11-21 Add support for clear commands from SPI
2021-11-21 added perspective trans matrix
2021-11-21 Use SInt through entire pipeline
    This fixes the clipping issue, as we now can "draw" outside the frame,
    and control clipping when drawing to the framebuffer.
2021-11-21 remove old serialization code without byte flipping
2021-11-21 Fit latest fpga protocol
2021-11-21 add metadata byte to package header
2021-11-21 Remove separate clear package
2021-11-21 Send multiple models
2021-11-21 Calculate MVP async
    This separates the calculation of all verteces in it's own statemachine,
    so that it will pre-caluclate points as soon as possible. Meaning the
    linedrawer can draw immediately.
2021-11-22 Add some regnexts to improve timing
2021-11-22 Refactor figure transmission
2021-11-22 Generate c files from obj files
2021-11-22 Separate game loop
2021-11-22 Implement support for clearing the framebuffer while reading
    This allows us to start clearing the framebuffer while reading, by just
    starting the clearing immediately and clear "after" the reading until
    the buffer is switched.
2021-11-22 Fixed padding issue
2021-11-22 Modified the C code to support multiple figures
2021-11-22 Demo with mario and tie fighter
2021-11-22 Added starfox ship
2021-11-22 Flipped y coordinates of generated models
2021-11-22 Add flag to pixel to say if it's behind -1 in z value from point or not
2021-11-22 Fix w normalization of z
2021-11-22 Boot screen
2021-11-22 script takes multiple files
2021-11-22 More models :)
2021-11-22 Increase point and line number alot & fix some bugs
2021-11-23 Reorder models and extend zoom out boundary
2021-11-23 Reset state when switching model
2021-11-23 Added new functionality.io
2021-11-23 Update Render_state_machine
