# Repository halworsen/tdt4295-grafikk

File README.md:

# Bugge

Bugge is an embedded system designed from absolute scratch, and is capable of drawing arbitrarily complex 3D wireframe models with VGA output. An onboard EFM32GG microcontroller receives inputs and communicates shapes to a Xilinx Artix-7 FPGA for graphics acceleration. Bugge was developed for the course TDT4295 (Datamaskinprosjekt/Computer project) at NTNU in the fall semester of 2021.

The project is separated into 3 independent parts:
* Electrical schematics & PCB routing
* Microcontroller code
* FPGA code

## KiCad design pcb/tdt4295/tdt4295.kicad_pcb

Parts:
C101, C105, C108, C109, C110: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C102: 10nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C103, C104, C111: 10uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C106, C107: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D101, D102, D103, D104: LED; LED_1206_3216Metric_Pad1.42x1.75mm_HandSolder
J101: ARM 20 Pin Debug Header; PinHeader_2x10_P1.27mm_Vertical_SMD
J102: MCU USART1 Header; PinHeader_2x06_P2.54mm_Vertical_SMD
J103: DM1AA-SF-PEJ(21); HRS_DM1AA-SF-PEJ(21)
J104: MCU GPIO Header; PinSocket_1x07_P2.54mm_Vertical_SMD_Pin1Right
R101, R102, R103, R104: 330; R_2512_6332Metric_Pad1.40x3.35mm_HandSolder
R105, R106: 15; RESC6332X120N
R107, R108, R109: 100; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R110, R111, R112, R113: 100K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
S101, S102, S103, S104: GPTS203211B; PushButton_12x12mm_THT_GPTS203211B; MPN GPTS203211B; Digi-Key_PN CW181-ND
U101: EFM32GG12B810F1024GQ64
U102, U103: COM-09032 Joystick; XDCR_COM-09032; PARTREV N/A
Y101: 48MHz; Crystal_SMD_2016-4Pin_2.0x1.6mm

Connections:
48MHZ_P1: U101.26 (PB14), Y101.1
48MHZ_P3: U101.25 (PB13), Y101.3
+5V: U101.52 (VBUS); also elsewhere on the board
DBG_SWCLK: J101.9, U101.49 (PF0)
DBG_SWDIO: J101.7, U101.50 (PF1)
DBG_SWO: J101.13, U101.51 (PF2)
FPGA_DONE: U101.15 (PB7); also elsewhere on the board
FPGA_MCU_GPIO_0: U101.62 (PE13); also elsewhere on the board
FPGA_MCU_GPIO_1: U101.61 (PE12); also elsewhere on the board
FPGA_MCU_GPIO_2: U101.54 (PF5); also elsewhere on the board
FPGA_MCU_GPIO_3: U101.53 (PF12); also elsewhere on the board
FPGA_MCU_USART_CLK: U101.3 (PA2); also elsewhere on the board
FPGA_MCU_USART_CS: U101.4 (PA3); also elsewhere on the board
FPGA_MCU_USART_CTS: U101.6 (PA5); also elsewhere on the board
FPGA_MCU_USART_RTS: U101.5 (PA4); also elsewhere on the board
FPGA_MCU_USART_RX: U101.1 (PA0); also elsewhere on the board
FPGA_MCU_USART_TX: U101.2 (PA1); also elsewhere on the board
FPGA_PROGRAM_B: U101.16 (PB8); also elsewhere on the board
GND: C101.2, C102.2, C103.2, C104.2, C105.2, C106.2, C107.2, C108.2, C109.2, C110.2, C111.2, J101.4, J101.6, J101.8, J101.10, J101.12, J101.14, J101.16, J101.18, J101.20, J102.2, J102.4, J102.6, J102.8, J102.10, J102.12, J103.3 (VSS1), J103.6 (VSS2), J104.7, R101.2, R102.2, R103.2, R104.2, S101.2, S102.2, S103.2, S104.2, U101.8 (VSS), U101.23 (VSS), U101.36 (VREGVSS), U101.56 (VSS), U102.H3 (H-), U102.V3 (V-), U103.H3 (H-), U103.V3 (V-), Y101.2, Y101.4; also elsewhere on the board
GPIO_BTN0: R110.2, S101.1, U101.9 (PB3)
GPIO_BTN1: R111.2, S102.1, U101.10 (PB4)
GPIO_BTN2: R112.2, S103.1, U101.11 (PB5)
GPIO_BTN3: R113.2, S104.1, U101.12 (PB6)
GPIO_JSH0: U101.19 (PA14), U102.H2 (H)
GPIO_JSH1: U101.17 (PA8), U103.H2 (H)
GPIO_JSV0: U101.18 (PA12), U102.V2 (V)
GPIO_JSV1: U101.34 (PD6), U103.V2 (V)
GPIO_LED0: D101.2 (A), U101.41 (PE4)
GPIO_LED1: D102.2 (A), U101.42 (PE5)
GPIO_LED2: D103.2 (A), U101.43 (PE6)
GPIO_LED3: D104.2 (A), U101.44 (PE7)
GPIO_PB11: R109.2, U101.21 (PB11)
GPIO_PB12: R108.2, U101.22 (PB12)
GPIO_PD8: R107.2, U101.35 (PD8)
MCU_RESETN: J101.15, U101.20 (RESETN)
unnamed: C106.1, U101.46 (VREGO)
unnamed: C107.1, U101.40 (DECOUPLE)
unnamed: D101.1 (K), R101.1
unnamed: D102.1 (K), R102.1
unnamed: D103.1 (K), R103.1
unnamed: D104.1 (K), R104.1
unnamed: J104.2, R107.1
unnamed: J104.3, R108.1
unnamed: J104.4, R109.1
unnamed: R105.2, U101.48 (PF11)
unnamed: R106.2, U101.47 (PF10)
unnamed: U102.S1 (SHIELD), U102.S2 (SHIELD), U102.S3 (SHIELD), U102.S4 (SHIELD)
unnamed: U103.S1 (SHIELD), U103.S2 (SHIELD), U103.S3 (SHIELD), U103.S4 (SHIELD)
SDIO_CD: J103.10 (CD), U101.13 (PC4)
SDIO_CLK: J103.5 (CLK), U101.63 (PE14)
SDIO_CMD: J103.2 (CMD), U101.64 (PE15)
SDIO_DAT0: J103.7 (DAT0), U101.60 (PE11)
SDIO_DAT1: J103.8 (DAT1), U101.59 (PE10)
SDIO_DAT2: J103.9 (DAT2), U101.58 (PE9)
SDIO_DAT3: J103.1 (CD/DAT3), U101.57 (PE8)
SDIO_WP: J103.11 (WP), U101.14 (PC5)
USART1_CLK: J102.5, U101.30 (PD2)
USART1_CS: J102.7, U101.31 (PD3)
USART1_CTS: J102.11, U101.32 (PD4)
USART1_RTS: J102.9, U101.33 (PD5)
USART1_RX: J102.3, U101.29 (PD1)
USART1_TX: J102.1, U101.28 (PD0)
USB_D+: R105.1; also elsewhere on the board
USB_D-: R106.1; also elsewhere on the board

Notes on the sheet:
EFM32GG MCU
See AN0002.1 Fig 3.3 & 2.6
See AN0002.1 Fig 3.3
RESETn has internal pullup
VREGI has internal p.down
AN0046 2.2
All button inputs are active low
SPI over USART
GPIO
FPGA <-> MCU connections

Parts:
C201, C202: 100uF; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
C203, C204, C216, C217, C218, C219: 22uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C205, C206, C214: 10uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C207, C208, C209, C212, C213, C215: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C210, C211: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D201, D202: LED; LED_1206_3216Metric_Pad1.42x1.75mm_HandSolder
FB201: Ferrite_Bead; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
L201, L203: 1.5uH; L_1008_2520Metric_Pad1.43x2.20mm_HandSolder
L202: 2.2uH; L_1008_2520Metric_Pad1.43x2.20mm_HandSolder
P201: 690-005-299-043; USB_Mini_B_Female_690-005-299-043; MPN 690-005-299-043; Digi-Key_PN 151-1206-1-ND
R201, R202: 330; R_2512_6332Metric_Pad1.40x3.35mm_HandSolder
R203: 30.1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R204, R207, R209: 22.1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R205: 100K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R206: 6.81K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R208: 73.2K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
TP201, TP202, TP203, TP204, TP205: TestPoint_Probe; TestPoint_Pad_D4.0mm
U201: PHDMI2AB4; DFN2510A-10
U202, U203: TPS54294; TPS54294PWP

Connections:
+1V0: C216.2, C218.2, L203.2, R206.1, TP204.1; also elsewhere on the board
+1V8: C203.2, C204.2, L201.1, R203.1, TP203.1; also elsewhere on the board
+5V: C202.1, C205.1, C206.1, C207.1, C208.1, C214.1, C215.1, D201.2 (A), FB201.1, TP201.1, U202.12 (EN2), U202.16 (VIN2), U203.1 (VIN1), U203.16 (VIN2); also elsewhere on the board
GND: C201.2, C202.2, C203.1, C204.1, C205.2, C206.2, C207.2, C208.2, C210.2, C211.2, C214.2, C215.2, C216.1, C217.1, C218.1, C219.1, P201.5, R201.2, R202.2, R204.2, R207.2, R209.2, TP205.1, U201.3 (GND), U201.8 (GND), U202.1 (VIN1), U202.4 (PGND1), U202.5 (EN1), U202.8 (GND), U202.13 (PGND2), U202.EPAD (PwrPad), U203.4 (PGND1), U203.8 (GND), U203.13 (PGND2), U203.EPAD (PwrPad); also elsewhere on the board
unnamed: C201.1, FB201.2, P201.1, U201.2 (LINE2)
unnamed: C209.1, U203.2 (VBST1)
unnamed: C209.2, L201.2, U203.3 (SW1)
unnamed: C210.1, U202.9 (VREG5)
unnamed: C211.1, R205.1, U203.9 (VREG5)
unnamed: C212.1, U203.15 (VBST2)
unnamed: C212.2, L202.1, U203.14 (SW2)
unnamed: C213.1, L203.1, U202.14 (SW2)
unnamed: C213.2, U202.15 (VBST2)
unnamed: D201.1 (K), R201.1
unnamed: D202.1 (K), R202.1
unnamed: R203.2, R204.1, U203.7 (VFB1)
unnamed: R205.2, U203.6 (PG1), U203.12 (EN2)
unnamed: R206.2, R207.1, U202.10 (VFB2)
unnamed: R208.2, R209.1, U203.10 (VFB2)
R1_PG: U202.11 (PG2), U203.5 (EN1)
USB_D+: P201.3, U201.4 (LINE3); also elsewhere on the board
USB_D-: P201.2, U201.1 (LINE1); also elsewhere on the board

Notes on the sheet:
Power input & Data lines
Power regulator - Stepdown 5V -> 1.0V/1.8V/3.3V
Power status LEDs & Hierarchical output
Probe points

Parts:
C301: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C302, C315: 47uF; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
C303: 330uF; T520V337M2R5ATE025
C304, C305, C307, C309, C310, C312, C317, C319: 4.7uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C306: 100uF; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
C308, C311, C313, C314, C316, C318, C320, C321, C322, C323, C324, C325, C326: 470nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D301: LED; LED_1206_3216Metric_Pad1.42x1.75mm_HandSolder
J301: FPGA__debug; PinHeader_2x07_P2.54mm_Vertical_SMD
R301: 2.4k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R302, R304, R305, R309: 4.7k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R303, R306: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R307: 200; R_2512_6332Metric_Pad1.40x3.35mm_HandSolder
R308: 100; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
U301: S25FL127SABMFV101
U302: NUP4114UCW1T2G
U303: XC7A100T-FTG256-tdt4295; Xilinx_FTG256

Connections:
+1V0: C303.1, C304.1, C305.1, C306.1, C307.1, C308.1, C309.1, C310.1, C311.1, C312.1, C313.1, C314.1, C316.1, C318.1, C320.1, C322.1, C324.1, C326.1, U303.E10 (VCCBRAM), U303.F7 (VCCINT), U303.F9 (VCCINT), U303.F11 (VCCBRAM), U303.G6 (VCCINT), U303.H9 (VCCINT), U303.J6 (VCCINT), U303.K9 (VCCINT), U303.L8 (VCCINT); also elsewhere on the board
+1V8: C315.1, C317.1, C319.1, C321.1, C323.1, C325.1, U303.G8 (VCCADC_0), U303.G10 (VCCAUX), U303.J10 (VCCAUX), U303.K11 (VCCAUX), U303.L10 (VCCAUX); also elsewhere on the board
/FPGA/IOB14/QSPI_CS: R301.2, U301.1 (*CS); also elsewhere on the board
/FPGA/IOB14/QSPI_DQ0: U301.5 (SI/IO0); also elsewhere on the board
/FPGA/IOB14/QSPI_DQ1: U301.2 (SO/IO1); also elsewhere on the board
/FPGA/IOB14/QSPI_DQ2: R304.2, U301.3 (*WP/IO2); also elsewhere on the board
/FPGA/IOB14/QSPI_DQ3: R309.2, U301.7 (*HOLD/IO3); also elsewhere on the board
/FPGA/TCK_JTAG: J301.6, R306.2, U302.4, U303.L7 (TCK_0)
/FPGA/TDI_JTAG: J301.10, U302.3, U303.N7 (TDI_0)
/FPGA/TDO_JTAG: J301.8, U302.1, U303.N8 (TDO_0)
/FPGA/TMS_JTAG: J301.4, R303.2, U302.6, U303.M7 (TMS_0)
FPGA_DONE: R307.2, R308.1, U303.H10 (DONE_0); also elsewhere on the board
FPGA_PROGRAM_B: R302.2, U303.L9 (PROGRAM_B_0); also elsewhere on the board
GND: C301.2, C302.2, C303.2, C304.2, C305.2, C306.2, C307.2, C308.2, C309.2, C310.2, C311.2, C312.2, C313.2, C314.2, C315.2, C316.2, C317.2, C318.2, C319.2, C320.2, C321.2, C322.2, C323.2, C324.2, C325.2, C326.2, D301.1 (K), J301.1, J301.3, J301.5, J301.7, J301.9, J301.11, J301.13, U301.4 (GND), U302.2, U303.A1 (GND), U303.A6 (VCCO_35), U303.A11 (GND), U303.B3 (VCCO_35), U303.B8 (GND), U303.C5 (GND), U303.C15 (GND), U303.D2 (GND), U303.D7 (VCCO_35), U303.D12 (GND), U303.E4 (VCCO_35), U303.E9 (GND), U303.F1 (VCCO_35), U303.F6 (GND), U303.F8 (VCCBATT_0), U303.F10 (GND), U303.F16 (GND), U303.G3 (GND), U303.G7 (GNDADC_0), U303.G9 (GND), U303.G13 (GND), U303.H6 (GND), U303.H7 (VREFN_0), U303.H8 (VP_0), U303.J2 (VCCO_35), U303.J7 (VN_0), U303.J8 (VREFP_0), U303.J9 (GND), U303.J11 (GND), U303.K4 (GND), U303.K6 (GND), U303.K14 (GND), U303.L1 (GND), U303.L11 (GND), U303.M3 (VCCO_34), U303.M8 (GND), U303.M10 (M1_0), U303.M11 (M2_0), U303.N5 (GND), U303.N15 (GND), U303.P2 (GND), U303.P12 (GND), U303.R4 (VCCO_34), U303.R9 (GND)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; also elsewhere on the board
unnamed: D301.2 (A), R308.2
unnamed: R305.2, U303.K10 (INIT_B_0)
unnamed: U301.6 (CLK), U303.E8 (CCLK_0)

Notes on the sheet:
VCCAUX
VCCINT
VCCBRAM

Parts:
C401: 47uF; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
C402, C403: 4.7uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C404, C405, C406, C407: 470nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
U303: XC7A100T-FTG256-tdt4295; Xilinx_FTG256

Connections:
FPGA_MCU_GPIO_0: U303.C13 (IO_L12N_T1_MRCC_15); also elsewhere on the board
FPGA_MCU_GPIO_1: U303.F13 (IO_L16N_T2_A27_15); also elsewhere on the board
FPGA_MCU_GPIO_2: U303.E16 (IO_L17P_T2_A26_15); also elsewhere on the board
FPGA_MCU_GPIO_3: U303.D16 (IO_L17N_T2_A25_15); also elsewhere on the board
FPGA_MCU_USART_CLK: U303.D13 (IO_L12P_T1_MRCC_15); also elsewhere on the board
FPGA_MCU_USART_CS: U303.B12 (IO_L5P_T0_AD9P_15); also elsewhere on the board
FPGA_MCU_USART_CTS: U303.D8 (IO_L6P_T0_15); also elsewhere on the board
FPGA_MCU_USART_RTS: U303.A12 (IO_L5N_T0_AD9N_15); also elsewhere on the board
FPGA_MCU_USART_RX: U303.B10 (IO_L4P_T0_15); also elsewhere on the board
FPGA_MCU_USART_TX: U303.A10 (IO_L3N_T0_DQS_AD1N_15); also elsewhere on the board
GND: C401.2, C402.2, C403.2, C404.2, C405.2, C406.2, C407.2; also elsewhere on the board

Parts:
C501: 1nF/250V; 8853522100131
D501, D502, D503, D504: LED; LED_1206_3216Metric_Pad1.42x1.75mm_HandSolder
J501: 618015330923
J502: FPGA GPIO; PinHeader_2x08_P2.54mm_Vertical_SMD
R501, R503, R505: 4k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R502, R504, R506: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R507, R508, R509, R510: 330; R_2512_6332Metric_Pad1.40x3.35mm_HandSolder
R511, R513, R515: 2k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R512, R514, R516: 510; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R517: 1M; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R518, R519: 100; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
U501, U502, U503, U504: NUP4114UCW1T2G

Connections:
FPGA_EXT_IO0: J502.1, U502.1 (I/0_1); also elsewhere on the board
FPGA_EXT_IO1: J502.3, U502.6 (I/0_2); also elsewhere on the board
FPGA_EXT_IO2: J502.5, U502.4 (I/0_4); also elsewhere on the board
FPGA_EXT_IO3: J502.7, U502.3 (I/0_3); also elsewhere on the board
FPGA_EXT_IO4: J502.9, U501.1 (I/0_1); also elsewhere on the board
FPGA_EXT_IO5: J502.11, U501.6 (I/0_2); also elsewhere on the board
FPGA_EXT_IO6: J502.13, U501.3 (I/0_3); also elsewhere on the board
FPGA_EXT_IO7: J502.2, U503.1 (I/0_1); also elsewhere on the board
FPGA_EXT_IO8: J502.4, U503.6 (I/0_2); also elsewhere on the board
FPGA_EXT_IO9: J502.6, U503.4 (I/0_4); also elsewhere on the board
FPGA_EXT_IO10: J502.8, U503.3 (I/0_3); also elsewhere on the board
FPGA_EXT_IO11: J502.10, U504.1 (I/0_1); also elsewhere on the board
FPGA_EXT_IO12: J502.12, U504.6 (I/0_2); also elsewhere on the board
FPGA_EXT_IO13: J502.14, U504.3 (I/0_3); also elsewhere on the board
FPGA_LED0: R507.2; also elsewhere on the board
FPGA_LED1: R508.2; also elsewhere on the board
FPGA_LED2: R509.2; also elsewhere on the board
FPGA_LED3: R510.2; also elsewhere on the board
GND: C501.1, D501.1 (K), D502.1 (K), D503.1 (K), D504.1 (K), J501.5, J501.6, J501.7, J501.8, J501.10, J502.15, R517.1, U501.2 (GND), U502.2 (GND), U503.2 (GND), U504.2 (GND); also elsewhere on the board
unnamed: C501.2, J501.SHELL, J501.SHELL1, R517.2
unnamed: D501.2 (A), R507.1
unnamed: D502.2 (A), R508.1
unnamed: D503.2 (A), R509.1
unnamed: D504.2 (A), R510.1
unnamed: J501.1, R501.1, R502.1, R511.1, R512.1
unnamed: J501.2, R503.1, R504.1, R513.1, R514.1
unnamed: J501.3, R505.1, R506.1, R515.1, R516.1
unnamed: J501.13, R518.1
unnamed: J501.14, R519.1
VGA_B0: R505.2; also elsewhere on the board
VGA_B1: R515.2; also elsewhere on the board
VGA_B2: R506.2; also elsewhere on the board
VGA_B3: R516.2; also elsewhere on the board
VGA_G0: R503.2; also elsewhere on the board
VGA_G1: R513.2; also elsewhere on the board
VGA_G2: R504.2; also elsewhere on the board
VGA_G3: R514.2; also elsewhere on the board
VGA_HS: R518.2; also elsewhere on the board
VGA_R0: R501.2; also elsewhere on the board
VGA_R1: R511.2; also elsewhere on the board
VGA_R2: R502.2; also elsewhere on the board
VGA_R3: R512.2; also elsewhere on the board
VGA_VS: R519.2; also elsewhere on the board

Notes on the sheet:
User LEDs
VGA output
GPIO header with ESD protection

Parts:
C601: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Digi-Key_PN 1276-1006-1-ND
C602: 47uF; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder; Digi-Key_PN 490-6543-1-ND
C603, C604: 4.7uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; Digi-Key_PN 445-7591-1-ND
C605, C606, C607, C608: 470nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Digi-Key_PN 490-3295-1-ND
U303: XC7A100T-FTG256-tdt4295; Xilinx_FTG256
U601: DSC1001AL5-100.0000; Digi-Key_PN DSC1001AL5-100.0000-ND

Connections:
/FPGA/IOB14/GCLK100: U303.N12 (IO_L13N_T2_MRCC_14), U601.3 (OUT)
/FPGA/IOB14/QSPI_CS: U303.L12 (IO_L6P_T0_FCS_B_14); also elsewhere on the board
/FPGA/IOB14/QSPI_DQ0: U303.J13 (IO_L1P_T0_D00_MOSI_14); also elsewhere on the board
/FPGA/IOB14/QSPI_DQ1: U303.J14 (IO_L1N_T0_D01_DIN_14); also elsewhere on the board
/FPGA/IOB14/QSPI_DQ2: U303.K15 (IO_L2P_T0_D02_14); also elsewhere on the board
/FPGA/IOB14/QSPI_DQ3: U303.K16 (IO_L2N_T0_D03_14); also elsewhere on the board
FPGA_EXT_IO0: U303.M12 (IO_L6N_T0_D08_VREF_14); also elsewhere on the board
FPGA_EXT_IO1: U303.M16 (IO_L7P_T1_D09_14); also elsewhere on the board
FPGA_EXT_IO2: U303.N16 (IO_L7N_T1_D10_14); also elsewhere on the board
FPGA_EXT_IO3: U303.P15 (IO_L8P_T1_D11_14); also elsewhere on the board
FPGA_EXT_IO4: U303.P16 (IO_L8N_T1_D12_14); also elsewhere on the board
FPGA_EXT_IO5: U303.R15 (IO_L9P_T1_DQS_14); also elsewhere on the board
FPGA_EXT_IO6: U303.R16 (IO_L9N_T1_DQS_D13_14); also elsewhere on the board
FPGA_EXT_IO7: U303.T14 (IO_L10P_T1_D14_14); also elsewhere on the board
FPGA_EXT_IO8: U303.T15 (IO_L10N_T1_D15_14); also elsewhere on the board
FPGA_EXT_IO9: U303.N13 (IO_L11P_T1_SRCC_14); also elsewhere on the board
FPGA_EXT_IO10: U303.P13 (IO_L11N_T1_SRCC_14); also elsewhere on the board
FPGA_EXT_IO11: U303.N14 (IO_L12P_T1_MRCC_14); also elsewhere on the board
FPGA_EXT_IO12: U303.P14 (IO_L12N_T1_MRCC_14); also elsewhere on the board
FPGA_EXT_IO13: U303.N11 (IO_L13P_T2_MRCC_14); also elsewhere on the board
FPGA_LED0: U303.R5 (IO_L23P_T3_A03_D19_14); also elsewhere on the board
FPGA_LED1: U303.T5 (IO_L23N_T3_A02_D18_14); also elsewhere on the board
FPGA_LED2: U303.R6 (IO_L24P_T3_A01_D17_14); also elsewhere on the board
FPGA_LED3: U303.R7 (IO_L24N_T3_A00_D16_14); also elsewhere on the board
GND: C601.1, C602.2, C603.2, C604.2, C605.2, C606.2, C607.2, C608.2, U303.L15 (IO_L3P_T0_DQS_PUDC_B_14), U601.2 (GND); also elsewhere on the board
VGA_B0: U303.N9 (IO_L18P_T2_A12_D28_14); also elsewhere on the board
VGA_B1: U303.P9 (IO_L18N_T2_A11_D27_14); also elsewhere on the board
VGA_B2: U303.M6 (IO_L19P_T3_A10_D26_14); also elsewhere on the board
VGA_B3: U303.N6 (IO_L19N_T3_A09_D25_VREF_14); also elsewhere on the board
VGA_G0: U303.P8 (IO_L20P_T3_A08_D24_14); also elsewhere on the board
VGA_G1: U303.R8 (IO_L20N_T3_A07_D23_14); also elsewhere on the board
VGA_G2: U303.T7 (IO_L21P_T3_DQS_14); also elsewhere on the board
VGA_G3: U303.T8 (IO_L21N_T3_DQS_A06_D22_14); also elsewhere on the board
VGA_HS: U303.T9 (IO_L22P_T3_A05_D21_14); also elsewhere on the board
VGA_R0: U303.R13 (IO_L16P_T2_CSI_B_14); also elsewhere on the board
VGA_R1: U303.T13 (IO_L16N_T2_A15_D31_14); also elsewhere on the board
VGA_R2: U303.R10 (IO_L17P_T2_A14_D30_14); also elsewhere on the board
VGA_R3: U303.R11 (IO_L17N_T2_A13_D29_14); also elsewhere on the board
VGA_VS: U303.T10 (IO_L22N_T3_A04_D20_14); also elsewhere on the board

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

Notices in the files:
parts and their libraries:
Copyright 2021 Accelerated Designs. All rights reserved.
Copyright 2016 Accelerated Designs. All rights reserved.
